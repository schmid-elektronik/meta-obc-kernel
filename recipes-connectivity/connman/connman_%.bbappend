
PACKAGECONFIG_append = " 3g wifi iptables bluez"